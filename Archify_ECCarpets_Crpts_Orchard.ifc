Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2025-10-14T09:30:23
Written by: ODA IFC SDK 22.8
Made in: 22.1.80.32 - Exporter 22.4.0.0 - Alternate UI 22.4.0.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status
COBie - Category: Project Information

# IfcSite, Default
RefLatitude: 51, 30, 0, 549316; RefLongitude: 0, -7, -34, -450321; RefElevation: 0 mm
COBie - Category: Project Information

# IfcBuilding
COBie - Category: Project Information

# IfcBuildingStorey: Level:Circle Head - Project Datum, Level 0
LongName: Level 0; Elevation: 0 mm
COBie - Category: Levels; Name: Level 0

# IfcCovering: Floor:Archify_ECCarpets_Carpets_Orchard_Akane2619, Floor:Archify_ECCarpets_Carpets_Orchard_Akane2619:221977
In: Level 0
Type - PredefinedType: FLOORING; Material: Archify_ECCarpets_Carpets_Orchard_Akane2619 9.5 mm
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: 0652:Carpets; CodePerformance: n/a; Color: n/a; Constituents: n/a; Description: Textured Tufted Loop Pile; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: n/a; Grade: n/a; Manufacturer: projects@eccarpets.com.au; Material: Nylon; ModelNumber: Akane 2619; ModelReference: Orchard; Name: Carpets_Orchard_Akane2619_ECCarpets; NominalWidth: 3660 mm; ReplacementCost: n/a; Shape: Rectangle; Size: n/a; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: Archify; BIMObjectName: Archify_ECCarpets_Carpets_Orchard_Akane2619; ManufacturerName: EC Carpets; ManufacturerURL: eccarpets.com.au; NCSCode: 0652; NCSTitle: Carpets; NCSVersion: October2024; ProductInformation: https://www.eccarpets.com.au/product/solution-dyed-nylon-carpets/orchard/; Uniclass2015Code: Pr_35_57_11_64; Uniclass2015Title: Pile carpets; Uniclass2015Version: Products v1.35; Version: 1
Type - IFC - IfcExportAs: IfcCoveringType; IfcExportType: FLOORING
Classification: Pr_35_57_11_64 (Uniclass2015)
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59

# IfcCovering: Floor:Archify_ECCarpets_Carpets_Orchard_Ashmead2607, Floor:Archify_ECCarpets_Carpets_Orchard_Ashmead2607:222597
In: Level 0
Type - PredefinedType: FLOORING; Material: Archify_ECCarpets_Carpets_Orchard_Ashmead2607 9.5 mm
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: 0652:Carpets; CodePerformance: n/a; Color: n/a; Constituents: n/a; Description: Textured Tufted Loop Pile; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: n/a; Grade: n/a; Manufacturer: projects@eccarpets.com.au; Material: Nylon; ModelNumber: Ashmead 2607; ModelReference: Orchard; Name: Carpets_Orchard_Ashmead2607_ECCarpets; NominalWidth: 3660 mm; ReplacementCost: n/a; Shape: Rectangle; Size: n/a; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: Archify; BIMObjectName: Archify_ECCarpets_Carpets_Orchard_Ashmead2607; ManufacturerName: EC Carpets; ManufacturerURL: eccarpets.com.au; NCSCode: 0652; NCSTitle: Carpets; NCSVersion: October2024; ProductInformation: https://www.eccarpets.com.au/product/solution-dyed-nylon-carpets/orchard/; Uniclass2015Code: Pr_35_57_11_64; Uniclass2015Title: Pile carpets; Uniclass2015Version: Products v1.35; Version: 1
Type - IFC - IfcExportAs: IfcCoveringType; IfcExportType: FLOORING
Classification: Pr_35_57_11_64 (Uniclass2015)
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59

# IfcCovering: Floor:Archify_ECCarpets_Carpets_Orchard_Calville2641, Floor:Archify_ECCarpets_Carpets_Orchard_Calville2641:222613
In: Level 0
Type - PredefinedType: FLOORING; Material: Archify_ECCarpets_Carpets_Orchard_Calville2641 9.5 mm
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: 0652:Carpets; CodePerformance: n/a; Color: n/a; Constituents: n/a; Description: Textured Tufted Loop Pile; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: n/a; Grade: n/a; Manufacturer: projects@eccarpets.com.au; Material: Nylon; ModelNumber: Calville 2641; ModelReference: Orchard; Name: Carpets_Orchard_Calville2641_ECCarpets; NominalWidth: 3660 mm; ReplacementCost: n/a; Shape: Rectangle; Size: n/a; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: Archify; BIMObjectName: Archify_ECCarpets_Carpets_Orchard_Calville2641; ManufacturerName: EC Carpets; ManufacturerURL: eccarpets.com.au; NCSCode: 0652; NCSTitle: Carpets; NCSVersion: October2024; ProductInformation: https://www.eccarpets.com.au/product/solution-dyed-nylon-carpets/orchard/; Uniclass2015Code: Pr_35_57_11_64; Uniclass2015Title: Pile carpets; Uniclass2015Version: Products v1.35; Version: 1
Type - IFC - IfcExportAs: IfcCoveringType; IfcExportType: FLOORING
Classification: Pr_35_57_11_64 (Uniclass2015)
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59

# IfcCovering: Floor:Archify_ECCarpets_Carpets_Orchard_Cameo2626, Floor:Archify_ECCarpets_Carpets_Orchard_Cameo2626:222627
In: Level 0
Type - PredefinedType: FLOORING; Material: Archify_ECCarpets_Carpets_Orchard_Cameo2626 9.5 mm
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: 0652:Carpets; CodePerformance: n/a; Color: n/a; Constituents: n/a; Description: Textured Tufted Loop Pile; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: n/a; Grade: n/a; Manufacturer: projects@eccarpets.com.au; Material: Nylon; ModelNumber: Cameo 2626; ModelReference: Orchard; Name: Carpets_Orchard_Cameo2626_ECCarpets; NominalWidth: 3660 mm; ReplacementCost: n/a; Shape: Rectangle; Size: n/a; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: Archify; BIMObjectName: Archify_ECCarpets_Carpets_Orchard_Cameo2626; ManufacturerName: EC Carpets; ManufacturerURL: eccarpets.com.au; NCSCode: 0652; NCSTitle: Carpets; NCSVersion: October2024; ProductInformation: https://www.eccarpets.com.au/product/solution-dyed-nylon-carpets/orchard/; Uniclass2015Code: Pr_35_57_11_64; Uniclass2015Title: Pile carpets; Uniclass2015Version: Products v1.35; Version: 1
Type - IFC - IfcExportAs: IfcCoveringType; IfcExportType: FLOORING
Classification: Pr_35_57_11_64 (Uniclass2015)
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59

# IfcCovering: Floor:Archify_ECCarpets_Carpets_Orchard_Cortland2604, Floor:Archify_ECCarpets_Carpets_Orchard_Cortland2604:222643
In: Level 0
Type - PredefinedType: FLOORING; Material: Archify_ECCarpets_Carpets_Orchard_Cortland2604 9.5 mm
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: 0652:Carpets; CodePerformance: n/a; Color: n/a; Constituents: n/a; Description: Textured Tufted Loop Pile; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: n/a; Grade: n/a; Manufacturer: projects@eccarpets.com.au; Material: Nylon; ModelNumber: Cortland 2604; ModelReference: Orchard; Name: Carpets_Orchard_Cortland2604_ECCarpets; NominalWidth: 3660 mm; ReplacementCost: n/a; Shape: Rectangle; Size: n/a; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: Archify; BIMObjectName: Archify_ECCarpets_Carpets_Orchard_Cortland2604; ManufacturerName: EC Carpets; ManufacturerURL: eccarpets.com.au; NCSCode: 0652; NCSTitle: Carpets; NCSVersion: October2024; ProductInformation: https://www.eccarpets.com.au/product/solution-dyed-nylon-carpets/orchard/; Uniclass2015Code: Pr_35_57_11_64; Uniclass2015Title: Pile carpets; Uniclass2015Version: Products v1.35; Version: 1
Type - IFC - IfcExportAs: IfcCoveringType; IfcExportType: FLOORING
Classification: Pr_35_57_11_64 (Uniclass2015)
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59

# IfcCovering: Floor:Archify_ECCarpets_Carpets_Orchard_Ida2637, Floor:Archify_ECCarpets_Carpets_Orchard_Ida2637:222661
In: Level 0
Type - PredefinedType: FLOORING; Material: Archify_ECCarpets_Carpets_Orchard_Ida2637 9.5 mm
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: 0652:Carpets; CodePerformance: n/a; Color: n/a; Constituents: n/a; Description: Textured Tufted Loop Pile; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: n/a; Grade: n/a; Manufacturer: projects@eccarpets.com.au; Material: Nylon; ModelNumber: Ida 2637; ModelReference: Orchard; Name: Carpets_Orchard_Ida2637_ECCarpets; NominalWidth: 3660 mm; ReplacementCost: n/a; Shape: Rectangle; Size: n/a; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: Archify; BIMObjectName: Archify_ECCarpets_Carpets_Orchard_Ida2637; ManufacturerName: EC Carpets; ManufacturerURL: eccarpets.com.au; NCSCode: 0652; NCSTitle: Carpets; NCSVersion: October2024; ProductInformation: https://www.eccarpets.com.au/product/solution-dyed-nylon-carpets/orchard/; Uniclass2015Code: Pr_35_57_11_64; Uniclass2015Title: Pile carpets; Uniclass2015Version: Products v1.35; Version: 1
Type - IFC - IfcExportAs: IfcCoveringType; IfcExportType: FLOORING
Classification: Pr_35_57_11_64 (Uniclass2015)
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59

# IfcCovering: Floor:Archify_ECCarpets_Carpets_Orchard_Jonamac2632, Floor:Archify_ECCarpets_Carpets_Orchard_Jonamac2632:222677
In: Level 0
Type - PredefinedType: FLOORING; Material: Archify_ECCarpets_Carpets_Orchard_Jonamac2632 9.5 mm
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: 0652:Carpets; CodePerformance: n/a; Color: n/a; Constituents: n/a; Description: Textured Tufted Loop Pile; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: n/a; Grade: n/a; Manufacturer: projects@eccarpets.com.au; Material: Nylon; ModelNumber: Jonamac 2632; ModelReference: Orchard; Name: Carpets_Orchard_Jonamac2632_ECCarpets; NominalWidth: 3660 mm; ReplacementCost: n/a; Shape: Rectangle; Size: n/a; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: Archify; BIMObjectName: Archify_ECCarpets_Carpets_Orchard_Jonamac2632; ManufacturerName: EC Carpets; ManufacturerURL: eccarpets.com.au; NCSCode: 0652; NCSTitle: Carpets; NCSVersion: October2024; ProductInformation: https://www.eccarpets.com.au/product/solution-dyed-nylon-carpets/orchard/; Uniclass2015Code: Pr_35_57_11_64; Uniclass2015Title: Pile carpets; Uniclass2015Version: Products v1.35; Version: 1
Type - IFC - IfcExportAs: IfcCoveringType; IfcExportType: FLOORING
Classification: Pr_35_57_11_64 (Uniclass2015)
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59

# IfcCovering: Floor:Archify_ECCarpets_Carpets_Orchard_Melrose2638, Floor:Archify_ECCarpets_Carpets_Orchard_Melrose2638:222691
In: Level 0
Type - PredefinedType: FLOORING; Material: Archify_ECCarpets_Carpets_Orchard_Melrose2638 9.5 mm
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: 0652:Carpets; CodePerformance: n/a; Color: n/a; Constituents: n/a; Description: Textured Tufted Loop Pile; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: n/a; Grade: n/a; Manufacturer: projects@eccarpets.com.au; Material: Nylon; ModelNumber: Melrose 2638; ModelReference: Orchard; Name: Carpets_Orchard_Melrose2638_ECCarpets; NominalWidth: 3660 mm; ReplacementCost: n/a; Shape: Rectangle; Size: n/a; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: Archify; BIMObjectName: Archify_ECCarpets_Carpets_Orchard_Melrose2638; ManufacturerName: EC Carpets; ManufacturerURL: eccarpets.com.au; NCSCode: 0652; NCSTitle: Carpets; NCSVersion: October2024; ProductInformation: https://www.eccarpets.com.au/product/solution-dyed-nylon-carpets/orchard/; Uniclass2015Code: Pr_35_57_11_64; Uniclass2015Title: Pile carpets; Uniclass2015Version: Products v1.35; Version: 1
Type - IFC - IfcExportAs: IfcCoveringType; IfcExportType: FLOORING
Classification: Pr_35_57_11_64 (Uniclass2015)
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59

# IfcCovering: Floor:Archify_ECCarpets_Carpets_Orchard_Sansa2628, Floor:Archify_ECCarpets_Carpets_Orchard_Sansa2628:222707
In: Level 0
Type - PredefinedType: FLOORING; Material: Archify_ECCarpets_Carpets_Orchard_Sansa2628 9.5 mm
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: 0652:Carpets; CodePerformance: n/a; Color: n/a; Constituents: n/a; Description: Textured Tufted Loop Pile; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: n/a; Grade: n/a; Manufacturer: projects@eccarpets.com.au; Material: Nylon; ModelNumber: Sansa 2628; ModelReference: Orchard; Name: Carpets_Orchard_Sansa2628_ECCarpets; NominalWidth: 3660 mm; ReplacementCost: n/a; Shape: Rectangle; Size: n/a; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: Archify; BIMObjectName: Archify_ECCarpets_Carpets_Orchard_Sansa2628; ManufacturerName: EC Carpets; ManufacturerURL: eccarpets.com.au; NCSCode: 0652; NCSTitle: Carpets; NCSVersion: October2024; ProductInformation: https://www.eccarpets.com.au/product/solution-dyed-nylon-carpets/orchard/; Uniclass2015Code: Pr_35_57_11_64; Uniclass2015Title: Pile carpets; Uniclass2015Version: Products v1.35; Version: 1
Type - IFC - IfcExportAs: IfcCoveringType; IfcExportType: FLOORING
Classification: Pr_35_57_11_64 (Uniclass2015)
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
